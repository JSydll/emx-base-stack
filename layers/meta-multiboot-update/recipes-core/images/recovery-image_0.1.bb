# -------------------------------------------------------------------
# Recovery only image
# -------------------------------------------------------------------
SUMMARY = "A recovery image with basic tooling support."

LICENSE = "MIT"

inherit recovery-image