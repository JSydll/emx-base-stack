# -------------------------------------------------------------------
# Core system only image
# -------------------------------------------------------------------
SUMMARY = "A system image with everything installed."

LICENSE = "MIT"

inherit system-image