# -------------------------------------------------------------------
# Core system only image
# -------------------------------------------------------------------
SUMMARY = "A custom system image with everything installed."

LICENSE = "MIT"

inherit custom-system-image