# -------------------------------------------------------------------
# Customized recovery image / rootfs
# -------------------------------------------------------------------
SUMMARY = "Customized recovery image / rootfs."

LICENSE = "MIT"

inherit recovery-image
require common-image-features.inc