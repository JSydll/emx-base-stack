require robust-filesystem-init-persistence.inc