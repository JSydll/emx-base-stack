# -------------------------------------------------------------------
# Full multiboot system image
# -------------------------------------------------------------------
SUMMARY = "An image with a complete partitioning and multiboot support."

LICENSE = "MIT"

inherit full-image

require definitions/${MACHINE}.inc