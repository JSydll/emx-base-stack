# -------------------------------------------------------------------
# Recovery only image
# -------------------------------------------------------------------
SUMMARY = "A custom recovery image with tooling support."

LICENSE = "MIT"

inherit custom-recovery-image